** GPIO **
*
* NI Multisim to SPICE Netlist Export
* Generated by: Gowthami
* Mon, Jun 08, 2020 23:32:30
*

*## Multisim Component S1 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS1 8 7   SwitchS1

.subckt SwitchS1 1 2
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
.MODEL NC_contact ISWITCH (Ion=0.05 Ioff=0.025 Ron=1e-8 Roff=1e30)
.ENDS

*## Multisim Component S2 ##*
* !!!BEGIN-INTERACT
*  2.0 constant high
*  0.0 constant low
*  2   constant max_states
*  low VARIABLE volt
*
*  :MAP_KEYBOARD_INPUT ++++K1 1 ++++k1 -1 ;
*
*  : UPDATE_SETTINGS
*     *animation_state max_states  low  high  STATE  volt
*     GRADUAL_CHANGE_AT_RUN
*  ;
*
*  :KEYBOARD_INPUT locals| shift_state |
*     shift_state *animation_state max_states NEXT_STATE_WRAP
*                                             ==>_*animation_state
*     UPDATE_SETTINGS
*  ;
*
*  :GRADUAL_CHANGE_AT_RUN locals| ref value |
*     value  SET_INSTANCE Vsource ::V  V2 dc
*  ;
*
*  : INIT_IMOUSE_OPTION
*    1 0 4 IMOUSE_SET
*  ;
*
*  : GET_IMOUSE_SUBCOMPS ( -- [iIdxN ... iIdx1] )
*    1
*  ;
*
*  : ON_SUBCOMP_IMOUSE_EVENT locals| eEventType nOptions iSubCompIdx |
*    eEventType 2 = if
*      -1
*      -1 KEYBOARD_INPUT
*    else
*      0
*    endif
*  ;
*
*  ( Initialize the settings )
*   UPDATE_SETTINGS
*   INIT_IMOUSE_OPTION
*
*  :BEGIN_PLOT
*     UPDATE_SETTINGS
*  ;
*
*  :BEGIN_ANALYSIS
*    UPDATE_SETTINGS
*  ;
*
* !!!END-INTERACT

xS2 3 6   SwitchS2

.subckt SwitchS2 1 2
V2 5 0 DC 0
R1 5 6 20
V1 6 0 DC 0
W0 2 1 V1 NC_contact
.MODEL NC_contact ISWITCH (Ion=0.05 Ioff=0.025 Ron=1e-8 Roff=1e30)
.ENDS

*## Multisim Component Venable ##*
aVenable dVenable.A dVenable.Y NOT__TIL__1

vVenable.PinVoltageA--1 1 Venable--1.1 DC 0.0

xVenable.Y dVenable.Y 5 TIL_DRV__NON__1

xVenable.A Venable--1.1 dVenable.A TIL_RCV__NON__1

*## Multisim Component U2 ##*
xU2 dU2.1 DIGITAL_CLOCK__DIGITAL_SOURCES__1 PARAMS: Frequency=1000 Duty=50 Delay=0

xU2.1 dU2.1 3 TIL_DRV__NON__1

*## Multisim Component U1 ##*
xU1 dU1.1 DIGITAL_CLOCK__DIGITAL_SOURCES__1 PARAMS: Frequency=1000 Duty=50 Delay=0

xU1.1 dU1.1 8 TIL_DRV__NON__1

*## Multisim Component enable ##*
aenable denable.OUT d_constsource_enable
.model d_constsource_enable   d_constsource(state=0)

xenable.OUT denable.OUT 1 TIL_DRV__NON__1

*## Multisim Instrument XMM2 ##*
XMM2 7 0 XXMM2_113416104

*## Multisim Component NMOS ##*
mNMOS 2 8 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=1e-005

*## Multisim Component NMOS3 ##*
mNMOS3 7 4 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=1e-005

*## Multisim Component NMOS4 ##*
mNMOS4 4 3 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=1e-005

*## Multisim Component PMOS3 ##*
mPMOS3 7 4 1 1 PMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=4e-006

*## Multisim Component PMOS4 ##*
mPMOS4 4 3 1 1 PMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=4e-006

*## Multisim Component NMOS2 ##*
mNMOS2 6 2 0 0 NMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=1e-005

*## Multisim Component PMOS2 ##*
mPMOS2 6 2 5 5 PMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=4e-006

*## Multisim Component PMOS ##*
mPMOS 2 8 5 5 PMOS__TRANSISTORS_VIRTUAL__1  L=1.8e-007  W=4e-006

*## Multisim Instrument XMM1 ##*
XMM1 6 0 XXMM1_113416104

.SUBCKT TIL_RCV__NON__1 1 2
* TIL Receiver Model  1 = input, 2 = A/D out
 aADCin1 [1] [2] ADC
.MODEL ADC adc_bridge (in_low= 2.5 in_high = 2.5)
.ENDS

.SUBCKT TIL_DRV__NON__1 1 2
* TIL Driver Model  1 = D/A input, 2 = out
 aDACin1 [1] [2] aDAC
.MODEL aDAC dac_bridge (out_low= 0 out_high = 5 out_undef = 2.5)
.ENDS

.MODEL NOT__TIL__1 d_inverter (rise_delay = 1n fall_delay = 1n)

.subckt XXMM2_113416104 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends

.model NMOS__TRANSISTORS_VIRTUAL__1   nmos

.subckt DIGITAL_CLOCK__DIGITAL_SOURCES__1 out PARAMS: Frequency=1k Duty=50 Delay=0
A1 out DigClock
.model DigClock d_clock (frequency={Frequency} duty={Duty/100} delay={Delay})
.ends

.model PMOS__TRANSISTORS_VIRTUAL__1 pmos

.subckt XXMM1_113416104 2 1
I_multi_meter 1 2 DC 0.000000e+000
R_multi_meter 2 1 1.000000e+009
.ends
